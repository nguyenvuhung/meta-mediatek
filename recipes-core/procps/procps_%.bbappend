# Enable forwarding ipv4: net/ipv4/ip_forward=1
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
